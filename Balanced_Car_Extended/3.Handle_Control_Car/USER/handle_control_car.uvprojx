# Keil uVision project handle_control_car.uvprojx, settings and files
target handle_control_car (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mpu6050 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000,USE_STM32F4_DISCOVERY
  c include: ..\BSP;..\CMSIS;..\FWLib\inc;..\USER;..\BSP\Delay;..\BSP\LED;..\BSP\Usart2;..\BSP\MPU6050;..\BSP\IIC_Software;..\BSP\INT_Sever;..\BSP\MPU6050\DMP;..\BSP\battery_adc;..\BSP\Beep;..\BSP\Encoder;..\BSP\Key;..\BSP\Motor;..\BSP\Oled;..\BSP\PS2;..\BSP\TIMER;..\APP\filter;..\APP\KF;..\APP;..\APP\PID
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c switch_function.h
  group CMSIS
    ../CMSIS/: core_cm4.c system_stm32f4xx.c startup_stm32f40xx.s
  group FWLib
    ../FWLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_syscfg.c
  group BSP
    ../BSP/Delay/: delay.c
    ../BSP/: bsp.c
    ../BSP/LED/: led.c
    ../BSP/Usart2/: usart1.c
    ../BSP/IIC_Software/: IOI2C.c
    ../BSP/INT_Sever/: intsever.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/battery_adc/: battery_adc.c
    ../BSP/Beep/: beep.c
    ../BSP/Encoder/: encoder.c
    ../BSP/Key/: key.c
    ../BSP/Motor/: motor.c
    ../BSP/Oled/: oled_i2c.c oled_fonts.c oled.c
    ../BSP/TIMER/: timer.c
    ../BSP/PS2/: ps2.c
  group DMP
    ../BSP/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group APP
    ../BSP/Motor/: app_motor.c
    ../BSP/PS2/: app_ps2.c
    ../APP/: app_control.c
    ../APP/PID/: pid_control.c
  group algorithm_my
    ../APP/filter/: filter.c
    ../APP/KF/: KF.c
